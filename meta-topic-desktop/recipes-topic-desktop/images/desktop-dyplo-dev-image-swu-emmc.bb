BASENAME = "desktop-dyplo-dev"

require recipes-core/images/swu-image-emmc-AB-partitions.inc
