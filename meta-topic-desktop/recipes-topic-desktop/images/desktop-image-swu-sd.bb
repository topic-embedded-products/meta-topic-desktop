BASENAME = "desktop"

require recipes-core/images/swu-image-sd-AB-partitions.inc
