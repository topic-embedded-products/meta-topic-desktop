BASENAME = "browser-desktop"

require recipes-core/images/swu-image-emmc-AB-partitions.inc
