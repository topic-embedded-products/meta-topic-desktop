DESCRIPTION = "Desktop image including a browser"

# Extending my-image
require desktop-image.bb

MY_DEVELOPMENT_EXTRAS += "\
	firefox \
	"
