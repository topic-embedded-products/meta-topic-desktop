BASENAME = "nix11"

require recipes-core/images/swu-image-emmc-AB-partitions.inc
