# Make fonts actually work in Qt5
PACKAGECONFIG_FONTS = "fontconfig"
