FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-xfce4-session-Show-splash-screen-at-boot-and-don-t-a.patch"

