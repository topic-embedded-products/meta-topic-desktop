FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-eglinfo-Workaround-compilation-with-old-headers.patch"

